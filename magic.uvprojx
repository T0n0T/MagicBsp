# Keil uVision project magic.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, STM32F103xE, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: rt-thread\components\dfs\dfs_v1\include;rt-thread\components\legacy\dfs;packages\CmBacktrace-v1.4.1;rt-thread\libcpu\arm\common;rt-thread\components\net\sal\include;rt-thread\components\net\sal\impl;applications;rt-thread\components\drivers\include;board;rt-thread\components\drivers\spi;rt-thread\components\net\netdev\include;packages\kawaii-mqtt\common;packages\kawaii-mqtt\mqtt;rt-thread\components\drivers\include;rt-thread\components\drivers\include;libraries\HAL_Drivers;board\CubeMX_Config\Inc;packages\kawaii-mqtt\common\log;libraries\HAL_Drivers\config;rt-thread\components\utilities\resource;rt-thread\components\net\sal\include\socket\sys_socket;rt-thread\components\drivers\include;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\common\extension;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\libc\posix\io\eventfd;.;rt-thread\components\net\at\include;packages\at_device-latest\inc;rt-thread\components\drivers\include;rt-thread\components\legacy;rt-thread\components\net\at\at_socket;packages\xpt2046-latest;packages\at_device-latest\class\esp8266;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;packages\kawaii-mqtt\network;rt-thread\include;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\posix\io\epoll;libraries\HAL_Drivers\CMSIS\Include;rt-thread\components\libc\posix\ipc;packages\kawaii-mqtt\platform\RT-Thread;rt-thread\components\drivers\include;rt-thread\components\net\sal\include\socket;rt-thread\components\drivers\include;rt-thread\components\dfs\dfs_v1\filesystems\devfs;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\kawaii-mqtt\mqttclient
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: decode.c ccm3310_test.c rt_kprintf.c drv_i2c.c cJSON.c crc32.c ccm3310.c app.c main.c
  group AT
    rt-thread/components/net/at/at_socket/: at_socket.c
    rt-thread/components/net/at/src/: at_utils.c at_cli.c at_client.c
  group at_device
    packages/at_device-latest/src/: at_device.c
    packages/at_device-latest/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
    packages/at_device-latest/samples/: at_sample_esp8266.c
  group cm_backtrace
    packages/CmBacktrace-v1.4.1/: cmb_port.c cm_backtrace.c cmb_flash_log.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/sensor/v1/: sensor.c sensor_cmd.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_rtc.c drv_soft_i2c.c drv_spi.c drv_tim.c drv_usart.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group kawaii_mqtt
    packages/kawaii-mqtt/network/: nettype_tls.c nettype_tcp.c network.c
    packages/kawaii-mqtt/mqtt/: MQTTConnectServer.c MQTTDeserializePublish.c MQTTSerializePublish.c MQTTSubscribeServer.c MQTTFormat.c MQTTUnsubscribeClient.c MQTTPacket.c MQTTUnsubscribeServer.c MQTTConnectClient.c MQTTSubscribeClient.c
    packages/kawaii-mqtt/common/log/arch/rt-thread/: arch.c
    packages/kawaii-mqtt/platform/RT-Thread/: platform_net_socket.c platform_timer.c platform_thread.c platform_memory.c platform_mutex.c
    packages/kawaii-mqtt/common/log/: format.c salof.c fifo.c
    packages/kawaii-mqtt/common/: random.c mqtt_list.c
    packages/kawaii-mqtt/mqttclient/: mqttclient.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Legacy
    rt-thread/components/legacy/ipc/: workqueue_legacy.c
  group Libraries
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_ll_spi.c stm32f1xx_hal_cortex.c stm32f1xx_hal_spi.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_i2c.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group max30102
    packages/max30102-latest/src/: max30102.c CircularBuffer.c
    packages/max30102-latest/examples/: example.c
    packages/max30102-latest/port/: port.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_at.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group Utilities
    rt-thread/components/utilities/resource/: resource_id.c
  group xpt2046_touch
    packages/xpt2046-latest/: drv_xpt2046.c

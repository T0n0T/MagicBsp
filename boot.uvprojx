# Keil uVision project boot.uvprojx, settings and files
target boot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: boot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,STM32F103xE
  c include: Core\Inc;Drivers\STM32F1xx_HAL_Driver\Inc;Drivers\CMSIS\Device\ST\STM32F1xx\Include;Drivers\CMSIS\Include;.cmsis\include;MDK-ARM\RTE\_boot;Middleware\sfud\inc;Modules
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Middleware/SFUD
    Middleware/sfud/port/: sfud_port.c
    Middleware/sfud/src/: sfud_sfdp.c sfud.c
  group Drivers/STM32F1xx_HAL_Driver
    Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_spi.c stm32f1xx_ll_usart.c stm32f1xx_ll_utils.c
  group Drivers/CMSIS
    Core/Src/: system_stm32f1xx.c
  group Application/User/Service
    Modules/: nor_flash.c printf.c
    ./Modules/: stmflash.c w25qxx.c
  group Application/User/Core
    Core/Src/: boot.c main.c stm32f1xx_it.c
  group Application/MDK-ARM
    MDK-ARM/: startup_stm32f103xe.s

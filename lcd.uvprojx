# Keil uVision project lcd.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, STM32F103xE, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: packages\LVGL-v8.3.1\src\extra\libs\fsdrv;packages\LVGL-v8.3.1\src\extra\widgets\win;packages\LVGL-v8.3.1\src\draw\nxp;packages\LVGL-v8.3.1\src\draw\nxp\vglite;packages\LVGL-v8.3.1\src\extra\themes\default;packages\LVGL-v8.3.1\src\extra\others\monkey;rt-thread\components\drivers\include;board\CubeMX_Config\Inc;libraries\HAL_Drivers\config;packages\LVGL-v8.3.1\src\extra\others;packages\LVGL-v8.3.1\src\extra\libs\qrcode;rt-thread\components\drivers\include;packages\LVGL-v8.3.1\src\extra\widgets\led;packages\LVGL-v8.3.1\src\extra\libs\sjpg;packages\LVGL-v8.3.1\env_support\rt-thread;rt-thread\include;packages\LVGL-v8.3.1\src\hal;libraries\HAL_Drivers\CMSIS\Include;packages\LVGL-v8.3.1\src\misc;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\posix\io\stdio;packages\LVGL-v8.3.1\src\extra\widgets\chart;packages\LVGL-v8.3.1\src\extra\others\snapshot;packages\LVGL-v8.3.1\src\draw\sdl;packages\LVGL-v8.3.1\src\draw\sw;rt-thread\libcpu\arm\common;packages\LVGL-v8.3.1\src\extra\libs\ffmpeg;applications;packages\LVGL-v8.3.1\src\extra\widgets\imgbtn;packages\LVGL-v8.3.1\src\extra\widgets\spinner;packages\LVGL-v8.3.1\src\extra\widgets\msgbox;.;libraries\HAL_Drivers\include;packages\LVGL-v8.3.1\src\extra\libs\bmp;packages\LVGL-v8.3.1\src\draw\stm32_dma2d;rt-thread\libcpu\arm\cortex-m3;packages\LVGL-v8.3.1\src\extra\others\imgfont;rt-thread\components\finsh;rt-thread\components\libc\compilers\common\extension;packages\LVGL-v8.3.1\src\extra\libs\png;packages\LVGL-v8.3.1\src\core;rt-thread\components\drivers\include;packages\LVGL-v8.3.1\src\font;packages\LVGL-v8.3.1\src\extra\widgets\list;packages\LVGL-v8.3.1\src\extra\layouts\flex;rt-thread\components\drivers\touch;packages\LVGL-v8.3.1\src\extra\layouts\grid;packages\LVGL-v8.3.1\src\extra\widgets;packages\LVGL-v8.3.1\src\extra\widgets\span;rt-thread\components\drivers\include;packages\LVGL-v8.3.1\src\extra\others\fragment;packages\LVGL-v8.3.1\src\extra\libs\gif;packages\LVGL-v8.3.1\src\widgets;packages\CmBacktrace-v1.4.1;packages\LVGL-v8.3.1\src\extra\themes;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;packages\LVGL-v8.3.1\src\extra\widgets\tileview;packages\LVGL-v8.3.1\src\extra\libs\freetype;packages\LVGL-v8.3.1\src\extra\themes\mono;packages\LVGL-v8.3.1\src\draw;packages\LVGL-v8.3.1\src\draw\nxp\pxp;rt-thread\components\drivers\include;packages\LVGL-v8.3.1\src\extra\widgets\menu;packages\LVGL-v8.3.1\src\extra\widgets\tabview;packages\LVGL-v8.3.1\src\extra\libs\rlottie;packages\LVGL-v8.3.1\src\extra\others\msg;packages\LVGL-v8.3.1\src\extra\themes\basic;packages\xpt2046-latest;rt-thread\components\drivers\spi\sfud\inc;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;packages\LVGL-v8.3.1\src\extra\libs;rt-thread\components\libc\posix\ipc;packages\LVGL-v8.3.1\src\draw\arm2d;packages\LVGL-v8.3.1\src\extra\widgets\spinbox;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;lcd_ILI9341;board;packages\LVGL-v8.3.1\src\extra\widgets\keyboard;rt-thread\components\libc\posix\io\poll;packages\LVGL-v8.3.1\src\draw\swm341_dma2d;packages\LVGL-v8.3.1\src\extra\widgets\calendar;packages\LVGL-v8.3.1\src\extra\others\gridnav;packages\LVGL-v8.3.1\src\extra\widgets\meter;packages\LVGL-v8.3.1\src\extra\widgets\colorwheel;packages\LVGL-v8.3.1\src\extra\widgets\animimg;rt-thread\components\legacy;packages\LVGL-v8.3.1\src;packages\LVGL-v8.3.1\src\extra;rt-thread\components\libc\compilers\common\include;packages\LVGL-v8.3.1\src\extra\others\ime;packages\LVGL-v8.3.1\src\extra\layouts;libraries\HAL_Drivers
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c lv_example_png_1.c img_wink_png.c lv_port_indev.c lv_port_disp.c
  group cm_backtrace
    packages/CmBacktrace-v1.4.1/: cmb_port.c cm_backtrace.c cmb_flash_log.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_dev_bus.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi-bit-ops.c spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_soft_spi.c drv_spi.c drv_tim.c drv_usart.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c object.c scheduler_up.c thread.c timer.c
  group LCD_ILI9341
    lcd_ILI9341/: bsp_lcd_ili9341.c
  group Legacy
    rt-thread/components/legacy/ipc/: workqueue_legacy.c
  group Libraries
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_ll_spi.c stm32f1xx_hal_cortex.c stm32f1xx_hal_spi.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group LVGL
    packages/LVGL-v8.3.1/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3.1/src/core/: lv_obj_draw.c lv_refr.c lv_obj_pos.c lv_obj_style_gen.c lv_obj.c lv_theme.c lv_obj_style.c lv_event.c lv_obj_scroll.c lv_group.c lv_disp.c lv_obj_tree.c lv_indev.c lv_indev_scroll.c lv_obj_class.c
    packages/LVGL-v8.3.1/src/font/: lv_font_fmt_txt.c lv_font_simsun_16_cjk.c lv_font_montserrat_32.c lv_font_unscii_8.c lv_font_montserrat_10.c lv_font_unscii_16.c lv_font_loader.c lv_font_montserrat_18.c lv_font_montserrat_24.c lv_font_montserrat_30.c lv_font_montserrat_28_compressed.c lv_font_montserrat_44.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_12.c lv_font_montserrat_16.c lv_font_montserrat_40.c lv_font_montserrat_22.c lv_font_montserrat_28.c lv_font.c lv_font_montserrat_46.c lv_font_montserrat_12_subpx.c lv_font_montserrat_20.c lv_font_montserrat_14.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_34.c lv_font_montserrat_8.c lv_font_montserrat_42.c lv_font_montserrat_26.c lv_font_montserrat_48.c
    packages/LVGL-v8.3.1/src/misc/: lv_tlsf.c lv_txt.c lv_utils.c lv_log.c lv_bidi.c lv_style_gen.c lv_mem.c lv_math.c lv_fs.c lv_style.c lv_anim_timeline.c lv_ll.c lv_color.c lv_anim.c lv_lru.c lv_templ.c lv_async.c lv_txt_ap.c lv_printf.c lv_timer.c lv_area.c lv_gc.c
    packages/LVGL-v8.3.1/src/draw/sw/: lv_draw_sw_blend.c lv_draw_sw_arc.c lv_draw_sw_line.c lv_draw_sw_img.c lv_draw_sw.c lv_draw_sw_rect.c lv_draw_sw_layer.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_polygon.c lv_draw_sw_letter.c lv_draw_sw_transform.c
    packages/LVGL-v8.3.1/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.1/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.1/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_stdio.c lv_fs_win32.c lv_fs_posix.c
    packages/LVGL-v8.3.1/src/draw/nxp/vglite/: lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_draw_vglite_arc.c lv_gpu_nxp_vglite.c
    packages/LVGL-v8.3.1/src/draw/sdl/: lv_draw_sdl_label.c lv_draw_sdl_arc.c lv_draw_sdl_composite.c lv_draw_sdl_stack_blur.c lv_draw_sdl_polygon.c lv_draw_sdl_line.c lv_draw_sdl.c lv_draw_sdl_img.c lv_draw_sdl_layer.c lv_draw_sdl_rect.c lv_draw_sdl_mask.c lv_draw_sdl_utils.c lv_draw_sdl_bg.c lv_draw_sdl_texture_cache.c
    packages/LVGL-v8.3.1/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.1/src/draw/: lv_draw_mask.c lv_draw_arc.c lv_img_decoder.c lv_draw_img.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_draw_layer.c lv_img_buf.c lv_draw_label.c lv_img_cache.c lv_draw_transform.c lv_draw.c
    packages/LVGL-v8.3.1/src/hal/: lv_hal_tick.c lv_hal_indev.c lv_hal_disp.c
    packages/LVGL-v8.3.1/src/widgets/: lv_slider.c lv_textarea.c lv_bar.c lv_img.c lv_btnmatrix.c lv_canvas.c lv_switch.c lv_table.c lv_roller.c lv_arc.c lv_btn.c lv_objx_templ.c lv_dropdown.c lv_checkbox.c lv_label.c lv_line.c
    packages/LVGL-v8.3.1/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.1/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-v8.3.1/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.1/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.1/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.1/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.1/src/draw/nxp/: lv_gpu_nxp.c
    packages/LVGL-v8.3.1/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.1/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.1/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.1/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.1/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.1/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.1/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.1/src/extra/: lv_extra.c
    packages/LVGL-v8.3.1/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.1/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.1/src/draw/nxp/pxp/: lv_gpu_nxp_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp_osa.c
    packages/LVGL-v8.3.1/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.1/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.1/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.1/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.3.1/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.1/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.1/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    packages/LVGL-v8.3.1/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.1/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.1/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.1/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.1/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.1/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.1/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.1/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3.1/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.1/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.1/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.1/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.1/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.1/src/extra/widgets/tileview/: lv_tileview.c
  group LVGL-port
    packages/LVGL-v8.3.1/env_support/rt-thread/: lv_rt_thread_port.c
  group xpt2046_touch
    packages/xpt2046-latest/: drv_xpt2046.c
